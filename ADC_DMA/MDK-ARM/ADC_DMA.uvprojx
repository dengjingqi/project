# Keil uVision project ADC_DMA.uvprojx, settings and files
target ADC_DMA (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ADC_DMA
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\USER;..\CORE;..\FWLIB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../USER/: main.c stm32f0xx_it.c system_stm32f0xx.c
  group STM32F0-Discovery
    ../CORE/: stm32f0_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../FWLIB/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group MDK-ARM
    ../CORE/: startup_stm32f0xx.s
